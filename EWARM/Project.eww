<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\env_management.ewp</path>
  </project>
  <batchBuild />
</workspace>
