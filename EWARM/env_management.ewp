# IAR project env_management.ewp, settings and files
configuration env_management (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/B-L475E-IOT01; ../Drivers/BSP/Components
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: env_management.hex
  ILINK.IlinkOutputFile: env_management.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User/Core
    ../Core/Src/: qspi.c sensors.c main.c gpio.c dfsdm.c i2c.c quadspi.c spi.c usart.c usb_otg.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/B-L475E-IOT01
    C:/Users/Lexington/STM32Cube/Repository/STM32Cube_FW_L4_V1.18.1/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01.h stm32l475e_iot01_accelero.c stm32l475e_iot01_accelero.h stm32l475e_iot01_gyro.c stm32l475e_iot01_gyro.h stm32l475e_iot01_hsensor.c stm32l475e_iot01_hsensor.h stm32l475e_iot01_magneto.c stm32l475e_iot01_magneto.h stm32l475e_iot01_psensor.c stm32l475e_iot01_psensor.h stm32l475e_iot01_qspi.c stm32l475e_iot01_qspi.h stm32l475e_iot01_tsensor.c stm32l475e_iot01_tsensor.h
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: hts221.c hts221.h
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl.h
    ../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb.h
    ../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
